# Keil uVision project EDP.uvprojx, settings and files
target 接收端 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 接收端 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Common;..\CORE;..\ESP8266;..\STM32\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\EDP;..\TIM;..\HARDWARE\LED;..\SYSTEM\delay;..\HARDWARE\car;..\HARDWARE\DHT11;..\HARDWARE\OLED_IIC;..\HARDWARE\fire
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group main
    ./: main.c system_stm32f10x.c stm32f10x_it.c
  group Core
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group STM32_Lib
    ../STM32/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group HardWare
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/car/: car.c
    ../HARDWARE/OLED_IIC/: OLED_IIC.c
    ./: fire.c
    ../HARDWARE/LED/: led.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group ESP8266
    ../ESP8266/: esp8266.c
  group EDP
    ../EDP/: EdpKit.c onenet.c
  group TIM
    ../TIM/: Tim.c
